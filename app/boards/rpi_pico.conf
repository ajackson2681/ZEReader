## app/boards/rpi_pico.conf
```kconfig
CONFIG_HEAP_MEM_POOL_SIZE=65536
CONFIG_LV_Z_DOUBLE_VDB=n
CONFIG_LV_Z_VDB_SIZE=100
```
